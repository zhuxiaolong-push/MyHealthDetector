# Keil uVision project HealthCheck.uvprojx, settings and files
target HealthCheck (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HealthCheck +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,NDEBUG
  c misc: --diag_suppress=68,111,188,223,546,1295,1362
  c include: .\User;.\Libraries\CMSIS;.\Libraries\FWlib;.\Libraries\FWlib\inc;.\Driver\Uart;.\Common\Com_Debug;.\Common\Com_Delay;.\Hardware\LCD;.\Middle\FreeRTOS\include;.\Middle\FreeRTOS\portable\MemMang;.\Middle\FreeRTOS\portable\RVDS\ARM_CM4F;.\Middle\FreeRTOS\source;.\Middle\LVGL\GUI\lvgl;.\Middle\LVGL\GUI\lvgl\examples\porting;.\Middle\LVGL\GUI\lvgl\src;.\Middle\LVGL\GUI\lvgl\src\core;.\Middle\LVGL\GUI\lvgl\src\draw;.\Middle\LVGL\GUI\lvgl\src\draw\nxp_pxp;.\Middle\LVGL\GUI\lvgl\src\draw\nxp_vglite;.\Middle\LVGL\GUI\lvgl\src\draw\sdl;.\Middle\LVGL\GUI\lvgl\src\draw\stm32_dma2d;.\Middle\LVGL\GUI\lvgl\src\draw\sw;.\Middle\LVGL\GUI\lvgl\src\extra;.\Middle\LVGL\GUI\lvgl\src\extra\layouts;.\Middle\LVGL\GUI\lvgl\src\extra\libs;.\Middle\LVGL\GUI\lvgl\src\extra\others;.\Middle\LVGL\GUI\lvgl\src\extra\themes;.\Middle\LVGL\GUI\lvgl\src\extra\widgets;.\Middle\LVGL\GUI\lvgl\src\font;.\Middle\LVGL\GUI\lvgl\src\hal;.\Middle\LVGL\GUI\lvgl\src\misc;.\Middle\LVGL\GUI\lvgl\src\widgets;.\Application\App_task;.\Application\App_GUI\GUI_main;.\Hardware\TOUCH;.\Common\Com_Sys;.\Hardware\MLX90614;.\Hardware\MAX30102;.\Hardware\W25Q16;.\Driver\SPI;.\Hardware\BUZZER;.\Hardware\ESP8266;.\Application\App_GUI\GUI_About;.\Application\App_GUI\GUI_Power;.\Application\App_GUI\GUI_Common;.\Application\App_GUI\GUI_Settings;.\Application\App_AutoSleep;.\Application\App_GUI\GUI_HeartRate;.\Hardware\KEY;.\Application\App_GUI\GUI_Temperature;.\Driver\BackLight
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c FreeRTOSConfig.h
  group Application/task
    ./Application/App_task/: App_task.c
    ./Application/App_AutoSleep/: APP_AutoSleep.c
  group Application/GUI
    ./Application/App_GUI/GUI_main/: GUI_main.c
    ./Application/App_GUI/GUI_About/: GUI_about.c
    ./Application/App_GUI/GUI_Power/: GUI_Power.c
    ./Application/App_GUI/GUI_Common/: GUI_Common.h
    ./Application/App_GUI/GUI_Settings/: GUI_Settings.c
    ./Application/App_GUI/GUI_HeartRate/: GUI_HeartRate.c
    ./Application/App_GUI/GUI_Temperature/: GUI_Temperature.c
  group Driver
    ./Driver/Uart/: uart.c
    ./Driver/SPI/: myspi.c
    ./Driver/BackLight/: backlight.c
  group Common
    ./Common/Com_Debug/: Com_Debug.c
    ./Common/Com_Delay/: Com_Delay.c
    ./Common/Com_Sys/: Com_Sys.c
  group Hardware
    ./Hardware/KEY/: Key.c
    ./Hardware/MLX90614/: mlx90614.c
    ./Hardware/MAX30102/: max30102.c
    ./Hardware/W25Q16/: W25Q16.c W25Q16.h W25Q16_Ins.h
    ./Hardware/BUZZER/: buzzer.c
    ./Hardware/ESP8266/: esp8266.c
  group Hardware/LCD
    ./Hardware/LCD/: LCD.c LCD.h
    ./Hardware/TOUCH/: ft5206.c ft5206.h gt9147.c gt9147.h ott2001a.c ott2001a.h touch.c touch.h ctiic.c ctiic.h
  group Libraries/FWlib
    ./Libraries/FWlib/: stm32f4xx_it.c stm32f4xx_it.h
    ./Libraries/FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Libraries/CMSIS
    ./Libraries/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group Middlewares/lvgl
    ./Middle/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./Middle/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./Middle/LVGL/GUI/lvgl/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ./Middle/LVGL/GUI/lvgl/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ./Middle/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./Middle/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./Middle/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ./Middle/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ./Middle/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./Middle/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./Middle/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./Middle/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./Middle/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./Middle/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./Middle/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./Middle/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./Middle/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./Middle/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./Middle/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./Middle/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./Middle/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ./Middle/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./Middle/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./Middle/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./Middle/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./Middle/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ./Middle/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./Middle/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./Middle/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./Middle/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/FreeRTOS
    ./Middle/FreeRTOS/include/: FreeRTOS.h
    ./Middle/FreeRTOS/portable/MemMang/: heap_4.c
    ./Middle/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ./Middle/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/lvgl/porting
    ./Middle/LVGL/GUI/lvgl/: lv_conf.h lvgl.h
    ./Middle/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_disp_template.h lv_port_indev_template.c lv_port_indev_template.h
